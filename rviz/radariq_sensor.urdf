Commit message: Clean up of code to match ROS conventions

File: rviz/radariq_sensor.urdf (robot description, URDF)
Before this commit: robot radariq_sensor, 1 links, 0 joints
Links:
- removed link map
- added link radar; visual box size=0.6 0.1 0.6
